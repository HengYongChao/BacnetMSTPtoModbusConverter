# IAR project ble_app_gls_pca10040_s132_spi.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: SPI_MASTER_0_ENABLE; BLE_STACK_SUPPORT_REQD; NRF_APP_VERSION_ADDR=0x1D000; NRF_APP_VERSION=0x00000001; SWI_DISABLE3; SVCALL_AS_NORMAL_FUNCTION; S132; NRF_SD_BLE_API_VERSION=3; BOARD_PCA10040; NRF52_PAN_12; NRF52_PAN_15; NRF52_PAN_20; NRF52_PAN_31; CONFIG_GPIO_AS_PINRESET; NRF52_PAN_36; NRF52_PAN_51; NRF52_PAN_54; NRF52_PAN_55; NRF52_PAN_58; NRF52_PAN_64; NRF52832; NRF52; SWI_DISABLE0
  ICCARM.CCIncludePath2: ..\..\..\config\ble_app_gls_pca10040_s132_spi; ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\ble\ble_advertising; ..\..\..\..\..\..\components\ble\ble_dtm; ..\..\..\..\..\..\components\ble\ble_racp; ..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c; ..\..\..\..\..\..\components\ble\ble_services\ble_ans_c; ..\..\..\..\..\..\components\ble\ble_services\ble_bas; ..\..\..\..\..\..\components\ble\ble_services\ble_bas_c; ..\..\..\..\..\..\components\ble\ble_services\ble_cscs; ..\..\..\..\..\..\components\ble\ble_services\ble_cts_c; ..\..\..\..\..\..\components\ble\ble_services\ble_dfu; ..\..\..\..\..\..\components\ble\ble_services\ble_dis; ..\..\..\..\..\..\components\ble\ble_services\ble_gls; ..\..\..\..\..\..\components\ble\ble_services\ble_hids; ..\..\..\..\..\..\components\ble\ble_services\ble_hrs; ..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c; ..\..\..\..\..\..\components\ble\ble_services\ble_hts; ..\..\..\..\..\..\components\ble\ble_services\ble_ias; ..\..\..\..\..\..\components\ble\ble_services\ble_ias_c; ..\..\..\..\..\..\components\ble\ble_services\ble_lbs; ..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c; ..\..\..\..\..\..\components\ble\ble_services\ble_lls; ..\..\..\..\..\..\components\ble\ble_services\ble_nus; ..\..\..\..\..\..\components\ble\ble_services\ble_nus_c; ..\..\..\..\..\..\components\ble\ble_services\ble_rscs; ..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c; ..\..\..\..\..\..\components\ble\ble_services\ble_tps; ..\..\..\..\..\..\components\ble\common; ..\..\..\..\..\..\components\ble\nrf_ble_qwr; ..\..\..\..\..\..\components\ble\peer_manager; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\adc; ..\..\..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\comp; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\i2s; ..\..\..\..\..\..\components\drivers_nrf\lpcomp; ..\..\..\..\..\..\components\drivers_nrf\pdm; ..\..\..\..\..\..\components\drivers_nrf\power; ..\..\..\..\..\..\components\drivers_nrf\ppi; ..\..\..\..\..\..\components\drivers_nrf\pwm; ..\..\..\..\..\..\components\drivers_nrf\qdec; ..\..\..\..\..\..\components\drivers_nrf\rng; ..\..\..\..\..\..\components\drivers_nrf\rtc; ..\..\..\..\..\..\components\drivers_nrf\saadc; ..\..\..\..\..\..\components\drivers_nrf\spi_master; ..\..\..\..\..\..\components\drivers_nrf\spi_slave; ..\..\..\..\..\..\components\drivers_nrf\swi; ..\..\..\..\..\..\components\drivers_nrf\timer; ..\..\..\..\..\..\components\drivers_nrf\twi_master; ..\..\..\..\..\..\components\drivers_nrf\twis_slave; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\drivers_nrf\usbd; ..\..\..\..\..\..\components\drivers_nrf\wdt; ..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\crc16; ..\..\..\..\..\..\components\libraries\crc32; ..\..\..\..\..\..\components\libraries\csense; ..\..\..\..\..\..\components\libraries\csense_drv; ..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\components\libraries\fds; ..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\components\libraries\fstorage; ..\..\..\..\..\..\components\libraries\gpiote; ..\..\..\..\..\..\components\libraries\hardfault; ..\..\..\..\..\..\components\libraries\hci; ..\..\..\..\..\..\components\libraries\led_softblink; ..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\components\libraries\low_power_pwm; ..\..\..\..\..\..\components\libraries\mem_manager; ..\..\..\..\..\..\components\libraries\pwm; ..\..\..\..\..\..\components\libraries\queue; ..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\components\libraries\sensorsim; ..\..\..\..\..\..\components\libraries\slip; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\twi; ..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\components\libraries\usbd; ..\..\..\..\..\..\components\libraries\usbd\class\audio; ..\..\..\..\..\..\components\libraries\usbd\class\cdc; ..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm; ..\..\..\..\..\..\components\libraries\usbd\class\hid; ..\..\..\..\..\..\components\libraries\usbd\class\hid\generic; ..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd; ..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse; ..\..\..\..\..\..\components\libraries\usbd\class\msc; ..\..\..\..\..\..\components\libraries\usbd\config; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\serialization\application\codecs\s132\serializers; ..\..\..\..\..\..\components\serialization\application\hal; ..\..\..\..\..\..\components\serialization\application\transport; ..\..\..\..\..\..\components\serialization\common; ..\..\..\..\..\..\components\serialization\common\struct_ser\s132; ..\..\..\..\..\..\components\serialization\common\transport; ..\..\..\..\..\..\components\serialization\common\transport\ser_phy; ..\..\..\..\..\..\components\serialization\common\transport\ser_phy\config; ..\..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\..\components\softdevice\s132\headers; ..\..\..\..\..\..\components\softdevice\s132\headers\nrf52; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\..\..\external\segger_rtt; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ble_app_gls_pca10040_s132_spi.hex
  ILINK.IlinkOutputFile: ble_app_gls_pca10040_s132_spi.out
  ILINK.IlinkIcfFile: ble_app_gls_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Log
    ../../../../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c sdk_mapped_flags.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../../components/libraries/crc16/: crc16.c
    ../../../../../../components/libraries/fds/: fds.c
    ../../../../../../components/libraries/fstorage/: fstorage.c
    ../../../../../../components/libraries/hardfault/: hardfault_implementation.c
    ../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../components/libraries/sensorsim/: sensorsim.c
  group Documentation
    ../../../: license.txt
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group nRF_Serialization
    ../../../../../../components/serialization/application/codecs/s132/serializers/: app_ble_gap_sec_keys.c app_ble_user_mem.c ble_app.c ble_event.c ble_evt_app.c ble_gap_app.c ble_gap_evt_app.c ble_gattc_app.c ble_gattc_evt_app.c ble_gatts_app.c ble_gatts_evt_app.c ble_l2cap_app.c ble_l2cap_evt_app.c nrf_soc_app.c
    ../../../../../../components/serialization/application/codecs/s132/middleware/: app_mw_ble.c app_mw_ble_gap.c app_mw_ble_gattc.c app_mw_ble_gatts.c app_mw_ble_l2cap.c app_mw_nrf_soc.c
    ../../../../../../components/serialization/common/struct_ser/s132/: ble_gap_struct_serialization.c ble_gatt_struct_serialization.c ble_gattc_struct_serialization.c ble_gatts_struct_serialization.c ble_struct_serialization.c nrf_soc_struct_serialization.c
    ../../../../../../components/serialization/common/: ble_serialization.c cond_field_serialization.c ser_dbg_sd_str.c
    ../../../../../../components/serialization/application/hal/: ser_app_hal_nrf5x.c ser_app_power_system_off.c
    ../../../../../../components/serialization/common/transport/: ser_hal_transport.c
    ../../../../../../components/serialization/common/transport/ser_phy/: ser_phy_spi_master.c
    ../../../../../../components/serialization/application/transport/: ser_sd_transport.c ser_softdevice_handler.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/hal/: nrf_nvmc.c
    ../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_soc.c
  group Board Support
    ../../../../../../components/libraries/bsp/: bsp.c bsp_btn_ble.c bsp_nfc.c
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../components/ble/ble_racp/: ble_racp.c
    ../../../../../../components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf52.s
    ../../../../../../components/toolchain/: system_nrf52.c
  group nRF_BLE_Services
    ../../../../../../components/ble/ble_services/ble_bas/: ble_bas.c
    ../../../../../../components/ble/ble_services/ble_dis/: ble_dis.c
    ../../../../../../components/ble/ble_services/ble_gls/: ble_gls.c ble_gls_db.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
