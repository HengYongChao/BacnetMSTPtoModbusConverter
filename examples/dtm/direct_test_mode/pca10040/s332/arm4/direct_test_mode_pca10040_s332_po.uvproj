# Keil uVision project direct_test_mode_pca10040_s332_po.uvproj, settings and files
target nrf52832_xxaa (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1
  c define: NRF52832 NRF52 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 CONFIG_GPIO_AS_PINRESET NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 S332 NRF_SD_BLE_API_VERSION=3 BSP_DEFINES_ONLY SOFTDEVICE_PRESENT
  c misc: --c99
  c include: ..\..\..\config\direct_test_mode_pca10040_s332_po;..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\s332\headers;..\..\..\..\..\..\components\softdevice\s332\headers\nrf52;..\..\..\..\..\..\components\toolchain;..\..\..;..\config
  asm define: as above
  asm misc: --cpreproc_opts=-DNRF52832,-DNRF52,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DCONFIG_GPIO_AS_PINRESET,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_64,-DS332,-DNRF_SD_BLE_API_VERSION=3,-DBSP_DEFINES_ONLY,-DSOFTDEVICE_PRESENT
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x29000 size 0x57000
  memory RVCT9: RAM 0x20001e30 size 0xe1d0
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf52.s
    ../../../../../../components/toolchain/: system_nrf52.c
  group Documentation
    ../../../: license.txt
  group nRF_BLE
    ../../../../../../components/ble/ble_dtm/: ble_dtm.c ble_dtm_hw_nrf52.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c
