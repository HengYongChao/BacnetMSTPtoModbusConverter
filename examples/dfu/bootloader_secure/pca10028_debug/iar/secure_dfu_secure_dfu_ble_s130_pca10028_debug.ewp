# IAR project secure_dfu_secure_dfu_ble_s130_pca10028_debug.ewp, settings and files
configuration nrf51422_xxac_s130 (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NRF_DFU_DEBUG_VERSION; BLE_STACK_SUPPORT_REQD; __HEAP_SIZE=0; SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION; S130; NRF_SD_BLE_API_VERSION=2; BOARD_PCA10028; SWI_DISABLE0; SOFTDEVICE_PRESENT; NRF51422; NRF51; NRF_DFU_SETTINGS_VERSION=1
  ICCARM.CCIncludePath2: ..\..\config\secure_dfu_secure_dfu_ble_s130_pca10028_debug; ..\..\config; ..\..\..\..\..\components; ..\..\..\..\..\components\ble\common; ..\..\..\..\..\components\boards; ..\..\..\..\..\components\device; ..\..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\components\drivers_nrf\rng; ..\..\..\..\..\components\libraries\bootloader; ..\..\..\..\..\components\libraries\bootloader\ble_dfu; ..\..\..\..\..\components\libraries\bootloader\dfu; ..\..\..\..\..\components\libraries\crc32; ..\..\..\..\..\components\libraries\crypto; ..\..\..\..\..\components\libraries\ecc; ..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\components\libraries\fstorage; ..\..\..\..\..\components\libraries\hci; ..\..\..\..\..\components\libraries\log; ..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\components\libraries\queue; ..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\components\libraries\sha256; ..\..\..\..\..\components\libraries\svc; ..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\components\libraries\util; ..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\components\softdevice\s130\headers; ..\..\..\..\..\components\softdevice\s130\headers\nrf51; ..\..\..\..\..\components\toolchain; ..\..\..\..\..\components\toolchain\cmsis\include; ..\..; ..\..\..\..\..\external\micro-ecc\micro-ecc; ..\..\..\..\..\external\nano-pb; ..\..\..\..\..\external\segger_rtt; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: secure_dfu_secure_dfu_ble_s130_pca10028_debug.hex
  ILINK.IlinkOutputFile: secure_dfu_secure_dfu_ble_s130_pca10028_debug.out
  ILINK.IlinkIcfFile: secure_dfu_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Log
    ../../../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Libraries
    ../../../../../components/libraries/util/: app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c
    ../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../../../../../components/libraries/crc32/: crc32.c
    ../../../../../components/libraries/ecc/: ecc.c
    ../../../../../components/libraries/fstorage/: fstorage.c
    ../../../../../components/libraries/hci/: hci_mem_pool.c
    ../../../../../components/libraries/crypto/: nrf_crypto.c
    ../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../components/libraries/sha256/: sha256.c
  group nano-pb
    ../../../../../external/nano-pb/: pb_common.c pb_decode.c
  group nRF_micro_ecc
    ../../../../../external/micro-ecc/nrf51_iar/armgcc/: micro_ecc_lib_nrf51.a
  group Board Definition
    ../../../../../components/boards/: boards.c
  group nRF_Drivers
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/rng/: nrf_drv_rng.c
    ../../../../../components/drivers_nrf/hal/: nrf_nvmc.c
  group Device
    ../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../components/toolchain/: system_nrf51.c
  group Application
    ../../: dfu-cc.pb.c dfu_public_key.c dfu_req_handling.c main.c
    ../config/: sdk_config.h
  group nRF_BLE_DFU
    ../../../../../components/libraries/bootloader/ble_dfu/: nrf_ble_dfu.c
  group nRF_Segger_RTT
    ../../../../../external/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group Documentation
    ../../: license.txt
  group nRF_BLE
    ../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
  group nRF_SoftDevice
    ../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
  group nRF_Bootloader
    ../../../../../components/libraries/bootloader/: nrf_bootloader.c nrf_bootloader_app_start.c nrf_bootloader_info.c
    ../../../../../components/libraries/bootloader/dfu/: nrf_dfu.c nrf_dfu_flash.c nrf_dfu_mbr.c nrf_dfu_settings.c nrf_dfu_transport.c nrf_dfu_utils.c
