# Keil uVision project gzll_dynamic_pairing_host_pca10031.uvproj, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_SD_HW_RESOURCES NRF51422 BOARD_PCA10031 GAZELL_PRESENT GAZELL_ALTERNATIVE_RESOURCES NRF51 SWI_DISABLE0
  c misc: --c99
  c include: ..\..\..\config\gzll_dynamic_pairing_host_pca10031;..\..\..\config;..\..\..\..\..\..\..\..\components;..\..\..\..\..\..\..\..\components\boards;..\..\..\..\..\..\..\..\components\device;..\..\..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\..\components\proprietary_rf\gzll;..\..\..\..\..\..\..\..\components\toolchain;..\..\..;..\..\..\..\..\..\..\..\external\segger_rtt;..\config
  asm define: as above
  asm misc: --cpreproc_opts=-DUSE_SD_HW_RESOURCES,-DNRF51422,-DBOARD_PCA10031,-DGAZELL_PRESENT,-DGAZELL_ALTERNATIVE_RESOURCES,-DNRF51,-DSWI_DISABLE0
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../../../components/boards/: boards.c
  group Board Support
    ../../../../../../../../components/libraries/bsp/: bsp.c bsp_nfc.c
  group Device
    ../../../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: license.txt
  group nRF_Drivers
    ../../../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../../../components/drivers_nrf/hal/: nrf_ecb.c nrf_nvmc.c
  group nRF_Libraries
    ../../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c
    ../../../../../../../../components/libraries/timer/: app_timer.c
  group nRF_Log
    ../../../../../../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Properitary_RF
    ../../../../../../../../components/proprietary_rf/gzll/arm/: gzll_nrf51_sd_resources_arm.lib
    ../../../../../../../../components/proprietary_rf/gzll/: nrf_gzp.c nrf_gzp_host.c nrf_gzp_host_nrf5x.c
  group nRF_Segger_RTT
    ../../../../../../../../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
