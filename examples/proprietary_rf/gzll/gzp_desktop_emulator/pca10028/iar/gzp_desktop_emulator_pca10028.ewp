# IAR project gzp_desktop_emulator_pca10028.ewp, settings and files
configuration nrf51422_xxac (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NRF51422; BOARD_PCA10028; BSP_SIMPLE; GAZELL_PRESENT; NRF51
  ICCARM.CCIncludePath2: ..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\proprietary_rf\gzll; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..; ..\..\..\..\..\..\external\segger_rtt; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: NRF51422; BOARD_PCA10028; BSP_SIMPLE; GAZELL_PRESENT; NRF51
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: gzp_desktop_emulator_pca10028.hex
  ILINK.IlinkOutputFile: gzp_desktop_emulator_pca10028.out
  ILINK.IlinkIcfFile: ..\..\..\gzp_device_iar_nrf51.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Log
    ../../../../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/uart/: app_uart_fifo.c retarget.c
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/hal/: nrf_ecb.c nrf_nvmc.c
  group Board Support
    ../../../../../../components/libraries/bsp/: bsp.c bsp_nfc.c
  group Application
    ../../: keyboard_emulator.c main_mouse_keyboard_emulator.c mouse_sensor_emulator.c
    ../config/: sdk_config.h
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group Documentation
    ../../: license.txt
  group nRF_Properitary_RF
    ../../../../../../components/proprietary_rf/gzll/iar/: gzll_nrf51_iar.a
    ../../../../../../components/proprietary_rf/gzll/: nrf_gzp.c nrf_gzp_device.c
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
