# Keil uVision project blinky_systick_pca10056.uvproj, settings and files
target nrf52840_xxaa (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52840_xxaa +hex
  c flags: Optim=4 OneElfS=1
  c define: NRF52840_XXAA CONFIG_GPIO_AS_PINRESET BOARD_PCA10056
  c misc: --c99
  c include: ..\..\..\config\blinky_systick_pca10056;..\..\..\config;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\drivers_nrf\systick;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\toolchain;..\..\..;..\config
  asm define: NRF52840_XXAA CONFIG_GPIO_AS_PINRESET BOARD_PCA10056
  asm misc: --cpreproc_opts=-DNRF52840_XXAA,-DCONFIG_GPIO_AS_PINRESET,-DBOARD_PCA10056
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf52840.s
    ../../../../../../components/toolchain/: system_nrf52840.c
  group Documentation
    ../../../: license.txt
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/systick/: nrf_drv_systick.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c nrf_assert.c
