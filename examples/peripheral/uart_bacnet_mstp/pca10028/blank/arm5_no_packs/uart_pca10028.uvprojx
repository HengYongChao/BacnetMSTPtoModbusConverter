# Keil uVision project uart_pca10028.uvprojx, settings and files
target nrf51422_xxac (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.12.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: NRF51422 BOARD_PCA10028 BSP_DEFINES_ONLY NRF51 BACDL_MSTP MAX_APDU=480
  c include: ..\config;..\..\..;..\..\..\config;..\..\..\config\uart_pca10028;..\..\..\..\..\..\components;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\simple_timer;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\external\segger_rtt;..\..\..\bacnet_user;..\..\..\..\..\..\external\bacnet-stack\src;..\..\..\..\..\..\external\bacnet-stack\include;..\..\..\..\..\..\external\bacnet-stack\demo\handler;..\..\..\..\..\..\external\bacnet-stack\demo\object
  asm define: NRF51422 BOARD_PCA10028 BSP_DEFINES_ONLY NRF51
  asm misc: --cpreproc_opts=-DNRF51422,-DBOARD_PCA10028,-DBSP_DEFINES_ONLY,-DNRF51
  asm include: ..\..\..\config\uart_pca10028;..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\toolchain;..\..\..;..\..\..\..\..\..\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group Documentation
    ../../../: license.txt
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/timer/: nrf_drv_timer.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../../../../../components/libraries/timer/: app_timer.c
  group nRF_Log
    ../../../../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group bacnet-stack-0.8.3
    ../../../../../../external/bacnet-stack/src/: abort.c apdu.c bacaddr.c bacapp.c bacdcode.c bacerror.c bacint.c bacreal.c bacstr.c crc.c dcc.c fifo.c iam.c ihave.c memcopy.c npdu.c rd.c reject.c ringbuf.c rp.c rpm.c whohas.c whois.c wp.c
  group bacnet-handlers
    ../../../../../../external/bacnet-stack/demo/handler/: h_dcc.c h_rd.c h_npdu.c h_rp.c h_rpm.c h_whohas.c h_whois.c h_wp.c noserv.c s_iam.c s_ihave.c txbuf.c
  group bacnet_user
    ../../../bacnet_user/: automac.c bacnet.c bo.c device.c dlmstp.c led.c rs485.c timer.c timer_sys.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.11.1
