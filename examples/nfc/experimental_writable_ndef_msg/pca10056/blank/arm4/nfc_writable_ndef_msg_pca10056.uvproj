# Keil uVision project nfc_writable_ndef_msg_pca10056.uvproj, settings and files
target nrf52840_xxaa (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52840_xxaa +hex
  c flags: Optim=4 OneElfS=1
  c define: NRF52840_XXAA CONFIG_GPIO_AS_PINRESET BOARD_PCA10056 BSP_DEFINES_ONLY
  c misc: --c99
  c include: ..\..\..\config\nfc_writable_ndef_msg_pca10056;..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\components\libraries\hardfault\nrf52;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\nfc\experimental_t4t_lib;..\..\..\..\..\..\components\nfc\experimental_t4t_lib\hal_t4t;..\..\..\..\..\..\components\nfc\ndef\generic\message;..\..\..\..\..\..\components\nfc\ndef\generic\record;..\..\..\..\..\..\components\nfc\ndef\uri;..\..\..\..\..\..\components\toolchain;..\..\..;..\..\..\..\..\..\external\segger_rtt;..\config
  asm define: as above
  asm misc: --cpreproc_opts=-DNRF52840_XXAA,-DCONFIG_GPIO_AS_PINRESET,-DBOARD_PCA10056,-DBSP_DEFINES_ONLY
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf52840.s
    ../../../../../../components/toolchain/: system_nrf52840.c
  group Documentation
    ../../../: license.txt
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../../components/libraries/hardfault/nrf52/handler/: hardfault_handler_keil.c
    ../../../../../../components/libraries/hardfault/: hardfault_implementation.c
  group nRF_Log
    ../../../../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_NFC
    ../../../../../../components/nfc/experimental_t4t_lib/hal_t4t/: hal_nfc_t4t.c
    ../../../../../../components/nfc/ndef/generic/message/: nfc_ndef_msg.c
    ../../../../../../components/nfc/ndef/generic/record/: nfc_ndef_record.c
    ../../../../../../components/nfc/experimental_t4t_lib/: nfc_t4t_lib_keil.lib
    ../../../../../../components/nfc/ndef/uri/: nfc_uri_msg.c nfc_uri_rec.c
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
